SUMMARY = "JDK17 - Recipe"
DESCRIPTION = "A recipe for JDK17 from GitHub."
LICENSE = "CLOSED"
BB_GIT_CLONE_FOR_SRC_URI = "1"
PSEUDO_DISABLED="1"
# Source repository
SRC_URI = "git://github.com/KarimZidan007/JDK17.git;protocol=https;branch=main"


SRCREV = "a8a4e681d8cb79e2d25c47225babf8800571a0bb"

